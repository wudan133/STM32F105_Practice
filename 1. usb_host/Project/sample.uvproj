# Keil uVision project sample.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: sample +hex
  c flags: Optim=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL,HSE_VALUE=8000000,USE_USB_OTG_FS
  c include: ..\Libraries\CMSIS;..\Libraries\FWlib\inc;..\User;..\User\SysTick;..\User\LED;..\User\Usart;..\User\Timer;..\User\Key;..\User\USB\STM32_USB_HOST_Library\Core\inc;..\User\USB\STM32_USB_OTG_Driver\inc;..\User\USB\USB_APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Setup
    ../Libraries/CMSIS/: system_stm32f10x.c
    ../Libraries/CMSIS/startup/: startup_stm32f10x_cl.s
  group Lib
    ../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group user
    ../User/: main.c stm32f10x_it.c
    ../User/LED/: Led.c
    ../User/SysTick/: SysTick.c
    ../User/Usart/: Usart.c
    ../User/Timer/: TiMbase.c
    ../User/Key/: Key.c
  group USB_OTG
    ../User/USB/STM32_USB_OTG_Driver/src/: usb_core.c usb_hcd.c usb_hcd_int.c
  group USB_HOST
    ../User/USB/STM32_USB_HOST_Library/Core/src/: usbh_core.c usbh_hcs.c usbh_ioreq.c usbh_stdreq.c
  group USB_APP
    ../User/USB/USB_APP/: usb_bsp.c usbh_usr.c
